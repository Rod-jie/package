# Keil uVision project 8axis.uvprojx, settings and files
target 12Axis (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: App +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_USB_OTG_FS,ARM_MATH_CM4,__FPU_PRESENT=1,__FPU_USED =1,ARM
  c include: ..\APP;..\LIB;..\InterLayer;..\APP\Config;..\APP\Tool;..\curve
  memory RVCT4: ROM 0x8040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Logic
    ../APP/PackageDevice/: ConMode .c LengthDifMode.c UnderFeedFlimMode.c FlyCut_Pou.c
  group APP
    ../APP/: AppInit.c FSM.c Reset.c LogicTerm.c Logic.c LogicNotUsed.c can_net.c
  group Tool
    ../APP/Tool/: AxisMove.c Tool.c UserTool.c
  group Config
    ../APP/: main.c
    ../APP/Config/: AxisConfig.c bsp_config.c EXIQ.c InterLayer.c
  group LIB
    ../LIB/: BspLib.h Interlayer_config.h lock.h BspLibA8I24O24_V00.01.00.lib INTERLAYER_VER01_10_03.lib Algorithm.h Algorithm_ver_00_00_06.lib
  group Startup
    ./: startup_stm32f40_41xxx.s
  group Doc
    ../: Readme.txt
